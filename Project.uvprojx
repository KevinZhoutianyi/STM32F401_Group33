# Keil uVision project Project.uvprojx, settings and files
target NUCLEO_F401RE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_FULL_LL_DRIVER
  c include: .\MYLIB\inc;.\LLLIB\inc;.\USER;.\SYS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./USER/: main.c
  group MYLIB
    ./MYLIB/src/: Motors_And_Encoders.c
  group SYS
    ./SYS/: system_stm32f4xx.c System_Functions.c startup_stm32f401xe.s
  group LLLIB
    ./LLLIB/src/: stm32f4xx_ll_utils.c stm32f4xx_ll_usart.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
